Commit message: changed cylinder link 2 radius value

File: urdf/hw_arm.urdf (robot description, URDF)
Before this commit: robot robot_arm, 4 links, 3 joints
Links:
- link cylinder_2: geometry visual cylinder length=1 radius=0.1
